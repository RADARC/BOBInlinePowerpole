# Repository RADARC/BOBInlinePowerpole

File README.md:

# BOBInlinePowerpole
Inline Anderson Powerpole protection based on the circuit by Bernard McIntosh GM4WZG and featured in the September 2021 issue of RadCom.

The original design used DMT6002 MOSFET's however these have been switched for SiR626ADP's in the Mouser parts list.
This was due to availability. The new part is slightly more expensive but has a slightly lower on resistance so will generate a fraction less heat.
It shares the same footprint so the PCB is compatible with either.

* Reverse polarity protection up to -40V
* Max input over voltage protection of 100V
* Output will only be enabled when the input is below +16V

# Notes
V1.1 has the over current feature removed as it is a little too sensitive. The below text has been left below as it gives good background information.  
~~A radio might come with a 25A fuse fitted but these take time to heat up and blow and it is possible a radio might have quite a high inrush current
which is fine for the fuse but due to the speed at which this circuit operates it could cause nuisance tripping. GM4WZG has had a few reports of this happening
mostly with Yaesu radios. The Mouser parts list includes an alternative 1.5 mOhm current sense resistor (R7) to increase the trip current to 33A.
You can always use a wire link instead of R7 if the current protection proves to be too problematic or you don't want the feature.
Note that the value of C4 can be used to limit the inrush current. However this is heavily dependant on the specific characteristics of the MOSFET's being used and
the amount of output capacitance which will be radio dependant. Therefore it is not possible to pick a value which will be suitable for everyone. 
See pages 12 & 13 of the LTC4368 datasheet for more information.~~

V1.1 also has the under voltage protection disabled as it was found that when turning on or connecting equipment the output was switched off and back on again at a rate of 30Hz.
This was caused by the input voltage dropping below the 11.5V threshold briefly due to the Watson W-30AM supply that was being used for testing not reacting quickly enough
to the sudden increase in current being drawn. If you wish to have the under voltage protection feature you can switch D1 for a 62K resistor.
NOTE: Using D1 I have realised that when operating in reverse polarity techniclly this causes the maximum -ve input to the UV pin of the chip to be exceeded. Id therefore now recommend
that D1 be omitted in most situations. Doing this does however reduce the max operating voltage to 80V instead of 100V. So in fixed installations it might be desirable
to keep the diode in place.

# Thermal Testing
Testing with a 55W car bulb so around a 4A load didnt show up any temperature difference. After a few minutes the only temperature rise was on output side of the PCB
which was caused by the heat from the H7 bulb traveliing back along the 6cm of wire and through the powerpole connector!

V0.1 was also tested with a 20A load and the PCB reached a temperature of just over 60C. This seemed to be a good compromise so when V1.1 was designed it was made just a
little shorter due to the current sense resistor being removed from the PCB but the width was kept the same.

# Versions
V0.1 First prototype  
V1.1 Removed over current protection feature & removed under voltage

# Current status
Complete

# 3D case
I have made the designs public in Tinkercad so people can modify it if they desire.
Print two copies of the design and clamp the two parts together using a M2 nut and screw though the centre of the powerpole connectors.
I used a 25mm long screw and cut it down to size.
There is also a stl for a small washer to sit between the top of the powerpole plug and the case to stop the case flexing when the screw is tightened.  
Case (print 2) - https://www.tinkercad.com/things/a7FUZU7CIxi  
Washer (print 2) - https://www.tinkercad.com/things/bhAzTZOGNlD

## KiCad design InlinePowerpoleBOB/InlinePowerpoleBOB.kicad_pcb

Parts:
C1: 220nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 100uF; CAPAE660X770N; Mouser Part Number 710-865080545012
D1: 15V; D_0805_2012Metric
IC1: LTC4368IMS-2#PBF; SOP50P490X110-10N; Mouser Part Number 584-LTC4368IMS2PBF
J1, J2: Anderson_Powerpole_2w; Anderson_powerpole_2w_90
Q1, Q2: DMT6002LPS-13; PowerDI5060-8
R1: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 24K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 750K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 1M3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.2, IC1.5 (GND), J1.2 (-ve), J2.2 (-ve), R2.2
unnamed: C1.1, IC1.4 (RETRY)
unnamed: C2.1, IC1.1 (VIN), J1.1 (+ve), Q1.3 (D), R1.1, R3.1, R5.1
unnamed: C3.1, C5.1, IC1.8 (VOUT), IC1.9 (SENSE), J2.1 (+ve), Q2.3 (D)
unnamed: C4.1, R6.2
unnamed: D1.1, IC1.2 (UV), R5.2
unnamed: IC1.3 (OV), R2.1, R3.2
unnamed: IC1.6 (~SHDN), R1.2
unnamed: IC1.10 (GATE), Q1.2 (G), Q2.2 (G), R6.1
unnamed: Q1.1 (S), Q2.1 (S)

Board: 2 copper layers, 60.3 x 36.8 mm, 16 parts (0 on the bottom side), 10 nets.

## Commit log

2021-09-02 PCB Updates
2021-09-02 Fixed PCB text
2021-09-02 Added note about over current tripping
2021-09-02 Added datasheets
2021-09-02 More info on inrush currents
2021-09-21 Removed over current feature
2021-09-21 Added 4A thermal testing
2021-09-21 Changed flir image from bmp to png
2021-10-12 V1.1 update
2021-10-12 Changed flir image to png
2021-11-01 Added 3D case
2021-11-02 Added spacer for case
2021-11-16 Added completed unit
2021-11-16 Added 3D view
2024-11-28 Rename IMG_4054.jpeg to Assembled PCB.jpeg
